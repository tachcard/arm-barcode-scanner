# IAR project Backup of Project.ewp, settings and files
configuration Discover-More (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX; NO_ICONV; USE_USB_OTG_FS
  ICCARM.CCIncludePath2: ..\; ..\inc; ..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32F4-Discovery; ..\..\..\Utilities\FatFs_vR0.08a; ..\src; ..\src\usblib; ..\..\..\Libraries\STM32_USB_Device_Library\Core\inc; ..\..\..\Libraries\STM32_USB_Device_Library\Class\msc\inc; ..\src\usb_flash; ..\..\..\Libraries\STM32_USB_Device_Library\Core\inc; ..\..\..\Libraries\STM32_USB_OTG_Driver\inc; ..\src\usb_com; ..\..\..\Libraries\STM32_USB_Device_Library\Class\cdc\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group EWARM
    ../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f4xx.s
  group FatFs
    ../../../Utilities/FatFs_vR0.08a/: diskio.c ff.c
  group Readme
    ../: readme.txt
  group STM32F4-Discovery
    ../../../Utilities/STM32F4-Discovery/: stm32f4_discovery.c stm32f4_discovery_lcd.c stm32f4_discovery_lis302dl.c stm32f4_discovery_sdio_sd.c
  group STM32F4xx_StdPeriph_Driver
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group USB Device/Class/CDC
    ../../../Libraries/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
  group USB Device/Class/MSC
    ../../../Libraries/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group USB Device/Library
    ../../../Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group USB Drivers
    ../../../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group User
    ../src/: bmp.c dcmi_ov9655.c image.s ImageReaderSource.cpp ImageReaderSource.h main.c main_bridge.cpp stm32f4xx_it.c system_stm32f4xx.c
  group User/usb_com
    ../src/usb_com/: usb_conf_com.h usbd_cdc_vcp.c usbd_cdc_vcp.h usbd_conf_com.h usbd_desc_com.c usbd_desc_com.h
  group User/usb_flash
    ../src/usb_flash/: usb_bsp.c usbd_desc.c usbd_desc.h usbd_storage_msd.c usbd_usr.c
  group zxing
    ../src/zxing/: BarcodeFormat.cpp BarcodeFormat.h Binarizer.cpp Binarizer.h BinaryBitmap.cpp BinaryBitmap.h ChecksumException.cpp ChecksumException.h DecodeHints.cpp DecodeHints.h Exception.cpp Exception.h FormatException.cpp FormatException.h IllegalStateException.h LuminanceSource.cpp LuminanceSource.h MultiFormatReader.cpp MultiFormatReader.h NotFoundException.h Reader.cpp Reader.h ReaderException.h Result.cpp Result.h ResultIO.cpp ResultPoint.cpp ResultPoint.h ResultPointCallback.cpp ResultPointCallback.h ZXing.h
  group zxing/common
    ../src/zxing/common/: Array.h BitArray.cpp BitArray.h BitArrayIO.cpp BitMatrix.cpp BitMatrix.h BitSource.cpp BitSource.h CharacterSetECI.cpp CharacterSetECI.h Counted.h DecoderResult.cpp DecoderResult.h DetectorResult.cpp DetectorResult.h FastHybridBinarizer.cpp FastHybridBinarizer.h GlobalHistogramBinarizer.cpp GlobalHistogramBinarizer.h GreyscaleLuminanceSource.cpp GreyscaleLuminanceSource.h GreyscaleRotatedLuminanceSource.cpp GreyscaleRotatedLuminanceSource.h GridSampler.cpp GridSampler.h HybridBinarizer.cpp HybridBinarizer.h IllegalArgumentException.cpp IllegalArgumentException.h PerspectiveTransform.cpp PerspectiveTransform.h Point.h Str.cpp Str.h StringUtils.cpp StringUtils.h
  group zxing/common/detector
    ../src/zxing/common/detector/: JavaMath.h MathUtils.h MonochromeRectangleDetector.cpp MonochromeRectangleDetector.h WhiteRectangleDetector.cpp WhiteRectangleDetector.h
  group zxing/common/reedsolomon
    ../src/zxing/common/reedsolomon/: GenericGF.cpp GenericGF.h GenericGFPoly.cpp GenericGFPoly.h ReedSolomonDecoder.cpp ReedSolomonDecoder.h ReedSolomonException.cpp ReedSolomonException.h
  group zxing/oned
    ../src/zxing/oned/: CodaBarReader.cpp CodaBarReader.h Code128Reader.cpp Code128Reader.h Code39Reader.cpp Code39Reader.h Code93Reader.cpp Code93Reader.h EAN13Reader.cpp EAN13Reader.h EAN8Reader.cpp EAN8Reader.h ITFReader.cpp ITFReader.h MultiFormatOneDReader.cpp MultiFormatOneDReader.h MultiFormatUPCEANReader.cpp MultiFormatUPCEANReader.h OneDReader.cpp OneDReader.h OneDResultPoint.cpp OneDResultPoint.h UPCAReader.cpp UPCAReader.h UPCEANReader.cpp UPCEANReader.h UPCEReader.cpp UPCEReader.h
  group zxing/qrcode
    ../src/zxing/qrcode/: ErrorCorrectionLevel.cpp ErrorCorrectionLevel.h FormatInformation.cpp FormatInformation.h QRCodeReader.cpp QRCodeReader.h Version.cpp Version.h
  group zxing/qrcode/decoder
    ../src/zxing/qrcode/decoder/: BitMatrixParser.cpp BitMatrixParser.h DataBlock.cpp DataBlock.h DataMask.cpp DataMask.h DecodedBitStreamParser.cpp DecodedBitStreamParser.h Decoder.cpp Decoder.h Mode.cpp Mode.h
  group zxing/qrcode/detector
    ../src/zxing/qrcode/detector/: AlignmentPattern.cpp AlignmentPattern.h AlignmentPatternFinder.cpp AlignmentPatternFinder.h Detector.cpp Detector.h FinderPattern.cpp FinderPattern.h FinderPatternFinder.cpp FinderPatternFinder.h FinderPatternInfo.cpp FinderPatternInfo.h
